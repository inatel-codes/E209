<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\exercicio_DCO.ewp</path>
    </project>
    <batchBuild />
</workspace>
